Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView]
File name: door.ifc
Time: 2026-09-09T00:00:00
Author: INVISIBLE DOORS
Organization: INVISIBLE DOORS
Written by: Showroom R15
Made in: Showroom R15

# IfcBuildingStorey, Finished floor
In: Building
Elevation: 0 m

# IfcDoor, Скрытая дверь 60мм Премиум
In: Finished floor
Description: Coordination geometry; not a native wall-hosted family; OverallHeight: 2.05885 m; OverallWidth: 0.8977 m; PredefinedType: DOOR; OperationType: SINGLE_SWING_RIGHT
INVISIBLE_DOORS_Configuration - Manufacturer: INVISIBLE DOORS; Model: skrytaya-dver-60mm; Finish: RAL 7032; FinishOutside: Эмаль · RAL 7032 · матовая; FinishInside: Как снаружи · Эмаль · RAL 7032 · матовая; Opening: right-out; Source: https://invisible-doors.ru/public_files/recommendations.pdf; GeometryUse: interior visualisation and coordination; operator GLB frame section; simplified hardware; LeafWidthMm: 800; LeafHeightMm: 2000; LeafThicknessMm: 60; FrameProfile: MIR9182 Премиум; FrameSectionMm: 60 x 44.85; FrameSourceSHA256: c6d54cd387177716f714f70794c9fcb5b0e06565e144d7e09d41f6535f5f3cd1
